# IAR project main.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F2132 MSP430F2132
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: hardware; systerm; users; adc; trsdata; schdule
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f2132.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    systerm/: common.h
    ./: main.c
  group hardware
    hardware/: A7139.c A7139.h A7139_CONFIG.c A7139_CONFIG.h adc.c adc.h digio.c digio.h led.c led.h spi.c spi.h
  group schdule
    schdule/: device.c device.h interrupt.c interrupt.h join.c join.h ProcessEvent.c ProcessEvent.h
  group system
    systerm/: board.c board.h defs.h delay.c delay.h int.c int.h mcu.c mcu.h sys.c sys.h timer.c timer.h types.h uart.c uart.h
