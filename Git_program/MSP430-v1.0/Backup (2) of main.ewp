# IAR project Backup (2) of main.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2132 MSP430F2132
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: hardware; systerm; users; adc
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2132.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: main.c
    trsdata/: trsdata.c trsdata.h
  group adc
    adc/: adc.c adc.h
  group hardware
    hardware/: A7129.c A7129.h A7139_CONFIG.c A7139_CONFIG.h digio.c digio.h led.c led.h spi.c spi.h
  group system
    systerm/: board.c board.h common.h defs.h delay.c delay.h int.c int.h mcu.c mcu.h sys.c sys.h timer.c timer.h types.h uart.c uart.h
